# Keil uVision project stm32_W5500.uvprojx, settings and files
target Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_W5500
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STM32_W5500;.\w5500_driver;.\w5500_driver\Ethernet\W5500;.\w5500_driver\Ethernet;.\w5500_ini;.\w5500_driver\Internet\DHCP;.\timer_ini
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
    ./w5500_driver/Ethernet/W5500/: w5500.c
    ./w5500_driver/Ethernet/: wizchip_conf.c socket.c
    ./w5500_ini/: w5500_ini.c
    ./w5500_driver/Internet/DHCP/: dhcp.c
    ./timer_ini/: timer_ini.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
